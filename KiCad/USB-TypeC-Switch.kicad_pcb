# Repository bluetiger9/USB-Type-C-Switch

File README.md:

# USB 3.x Type-C Switch

Design idea:
https://www.element14.com/community/message/298495/l/usb-3x-type-c-switch-kvm-type-design-review#298495

# Features

The device will have the following features:

- two USB 3.x Type-C Input ports
- one USB 3.x Type-C Output port
- switching of all four USB 3.x SuperSpeed differential pairs
- switching of the USB 2.x HighSpeed differential pair
- switching of the Configuration (CC) and Sideband use (SBU) channels
- USB Power Delivery pass-through up to the full power range 20V @ 5A
- reasonable cost

## KiCad design KiCad/USB-TypeC-Switch.kicad_pcb

Parts:
C9: 100n; C_0603_1608Metric
H1, H2, H3, H4: MountingHole; MountingHole_2.5mm
J1: USB_C_IN_1; CUI_UJ31-CH-31-SMT-TR
J2: USB_C_IN_2; CUI_UJ31-CH-31-SMT-TR
J3: USB_C_OUT; CUI_UJ31-CH-31-SMT-TR
R23: 100k; R_0603_1608Metric

Connections:
/Control/D_uC_N: J2.A7 (D-), J2.B7 (D-); also elsewhere on the board
/Control/D_uC_P: J2.A6 (D+), J2.B6 (D+); also elsewhere on the board
/Power Switching and Supplies/VBUS: J3.A4 (VBUS), J3.A9 (VBUS), J3.B4 (VBUS), J3.B9 (VBUS); also elsewhere on the board
/Power Switching and Supplies/VBUS_1: J1.A4 (VBUS), J1.A9 (VBUS), J1.B4 (VBUS), J1.B9 (VBUS); also elsewhere on the board
/Power Switching and Supplies/VBUS_2: J2.A4 (VBUS), J2.A9 (VBUS), J2.B4 (VBUS), J2.B9 (VBUS); also elsewhere on the board
/USB 2.0 and Misc Signal Switching/CC1: J3.A5 (CC1); also elsewhere on the board
/USB 2.0 and Misc Signal Switching/CC1_1: J1.A5 (CC1); also elsewhere on the board
/USB 2.0 and Misc Signal Switching/CC1_2: J2.A5 (CC1); also elsewhere on the board
/USB 2.0 and Misc Signal Switching/CC2: J3.B5 (CC2); also elsewhere on the board
/USB 2.0 and Misc Signal Switching/CC2_1: J1.B5 (CC2); also elsewhere on the board
/USB 2.0 and Misc Signal Switching/CC2_2: J2.B5 (CC2); also elsewhere on the board
/USB 2.0 and Misc Signal Switching/D_1_N: J1.A7 (D-), J1.B7 (D-); also elsewhere on the board
/USB 2.0 and Misc Signal Switching/D_1_P: J1.A6 (D+), J1.B6 (D+); also elsewhere on the board
/USB 2.0 and Misc Signal Switching/D_N: J3.A7 (D-), J3.B7 (D-); also elsewhere on the board
/USB 2.0 and Misc Signal Switching/D_P: J3.A6 (D+), J3.B6 (D+); also elsewhere on the board
/USB 2.0 and Misc Signal Switching/SBU1: J3.A8 (SBU1); also elsewhere on the board
/USB 2.0 and Misc Signal Switching/SBU1_1: J1.A8 (SBU1); also elsewhere on the board
/USB 2.0 and Misc Signal Switching/SBU1_2: J2.A8 (SBU1); also elsewhere on the board
/USB 2.0 and Misc Signal Switching/SBU2: J3.B8 (SBU2); also elsewhere on the board
/USB 2.0 and Misc Signal Switching/SBU2_1: J1.B8 (SBU2); also elsewhere on the board
/USB 2.0 and Misc Signal Switching/SBU2_2: J2.B8 (SBU2); also elsewhere on the board
/USB 3 Signal Switching/RX1_1_N: J1.B10 (RX1-); also elsewhere on the board
/USB 3 Signal Switching/RX1_1_P: J1.B11 (RX1+); also elsewhere on the board
/USB 3 Signal Switching/RX1_2_N: J2.B10 (RX1-); also elsewhere on the board
/USB 3 Signal Switching/RX1_2_P: J2.B11 (RX1+); also elsewhere on the board
/USB 3 Signal Switching/RX1_N: J3.B10 (RX1-); also elsewhere on the board
/USB 3 Signal Switching/RX1_P: J3.B11 (RX1+); also elsewhere on the board
/USB 3 Signal Switching/RX2_1_N: J1.A10 (RX2-); also elsewhere on the board
/USB 3 Signal Switching/RX2_1_P: J1.A11 (RX2+); also elsewhere on the board
/USB 3 Signal Switching/RX2_2_N: J2.A10 (RX2-); also elsewhere on the board
/USB 3 Signal Switching/RX2_2_P: J2.A11 (RX2+); also elsewhere on the board
/USB 3 Signal Switching/RX2_N: J3.A10 (RX2-); also elsewhere on the board
/USB 3 Signal Switching/RX2_P: J3.A11 (RX2+); also elsewhere on the board
/USB 3 Signal Switching/TX1_1_N: J1.A3 (TX1-); also elsewhere on the board
/USB 3 Signal Switching/TX1_1_P: J1.A2 (TX1+); also elsewhere on the board
/USB 3 Signal Switching/TX1_2_N: J2.A3 (TX1-); also elsewhere on the board
/USB 3 Signal Switching/TX1_2_P: J2.A2 (TX1+); also elsewhere on the board
/USB 3 Signal Switching/TX1_N: J3.A3 (TX1-); also elsewhere on the board
/USB 3 Signal Switching/TX1_P: J3.A2 (TX1+); also elsewhere on the board
/USB 3 Signal Switching/TX2_1_N: J1.B3 (TX2-); also elsewhere on the board
/USB 3 Signal Switching/TX2_1_P: J1.B2 (TX2+); also elsewhere on the board
/USB 3 Signal Switching/TX2_2_N: J2.B3 (TX2-); also elsewhere on the board
/USB 3 Signal Switching/TX2_2_P: J2.B2 (TX2+); also elsewhere on the board
/USB 3 Signal Switching/TX2_N: J3.B3 (TX2-); also elsewhere on the board
/USB 3 Signal Switching/TX2_P: J3.B2 (TX2+); also elsewhere on the board
GND: C9.2, J1.A1 (GND), J1.A12 (GND), J1.B1 (GND), J1.B12 (GND), J2.A1 (GND), J2.A12 (GND), J2.B1 (GND), J2.B12 (GND), J3.A1 (GND), J3.A12 (GND), J3.B1 (GND), J3.B12 (GND), R23.1; also elsewhere on the board
GNDS: C9.1, J1.S1 (SHIELD), J2.S1 (SHIELD), J3.S1 (SHIELD), R23.2

Parts:
R6: 10k; R_0603_1608Metric
U1, U2: FUSB340TMX; QFN40P200X280X40-19N; PARTREV 2

Connections:
+3V3: R6.1, U1.17 (VDD), U2.17 (VDD); also elsewhere on the board
/Control/OE_N_USB3: R6.2, U1.7 (~OE), U2.7 (~OE); also elsewhere on the board
/Control/SEL_USB3: U1.6 (S), U2.6 (S); also elsewhere on the board
/USB 3 Signal Switching/RX1_1_N: U1.9 (SSRX2-); also elsewhere on the board
/USB 3 Signal Switching/RX1_1_P: U1.8 (SSRX2+); also elsewhere on the board
/USB 3 Signal Switching/RX1_2_N: U1.11 (SSRX1-); also elsewhere on the board
/USB 3 Signal Switching/RX1_2_P: U1.10 (SSRX1+); also elsewhere on the board
/USB 3 Signal Switching/RX1_N: U1.5 (SSRXCOM+); also elsewhere on the board
/USB 3 Signal Switching/RX1_P: U1.4 (SSRXCOM-); also elsewhere on the board
/USB 3 Signal Switching/RX2_1_N: U2.13 (SSTX2+); also elsewhere on the board
/USB 3 Signal Switching/RX2_1_P: U2.14 (SSTX2-); also elsewhere on the board
/USB 3 Signal Switching/RX2_2_N: U2.15 (SSTX1+); also elsewhere on the board
/USB 3 Signal Switching/RX2_2_P: U2.16 (SSTX1-); also elsewhere on the board
/USB 3 Signal Switching/RX2_N: U2.1 (SSTXCOM-); also elsewhere on the board
/USB 3 Signal Switching/RX2_P: U2.2 (SSTXCOM+); also elsewhere on the board
/USB 3 Signal Switching/TX1_1_N: U2.9 (SSRX2-); also elsewhere on the board
/USB 3 Signal Switching/TX1_1_P: U2.8 (SSRX2+); also elsewhere on the board
/USB 3 Signal Switching/TX1_2_N: U2.11 (SSRX1-); also elsewhere on the board
/USB 3 Signal Switching/TX1_2_P: U2.10 (SSRX1+); also elsewhere on the board
/USB 3 Signal Switching/TX1_N: U2.5 (SSRXCOM+); also elsewhere on the board
/USB 3 Signal Switching/TX1_P: U2.4 (SSRXCOM-); also elsewhere on the board
/USB 3 Signal Switching/TX2_1_N: U1.13 (SSTX2+); also elsewhere on the board
/USB 3 Signal Switching/TX2_1_P: U1.14 (SSTX2-); also elsewhere on the board
/USB 3 Signal Switching/TX2_2_N: U1.15 (SSTX1+); also elsewhere on the board
/USB 3 Signal Switching/TX2_2_P: U1.16 (SSTX1-); also elsewhere on the board
/USB 3 Signal Switching/TX2_N: U1.1 (SSTXCOM-); also elsewhere on the board
/USB 3 Signal Switching/TX2_P: U1.2 (SSTXCOM+); also elsewhere on the board
GND: U1.3 (GND), U1.12 (GND), U1.18 (GND), U1.19 (EP), U2.3 (GND), U2.12 (GND), U2.18 (GND), U2.19 (EP); also elsewhere on the board

Parts:
Q1, Q2, Q3, Q4, Q5, Q6: AP1606; Diodes_DFN1006-3
R7, R8, R20, R21, R27, R28: 220k; R_0402_1005Metric
R11, R12, R22, R24, R25, R26: 5.1k; R_0402_1005Metric
S1: DG2788ADN-T1-GE4; QFN40P180X260X60-16N-D; Manufacturer_Part_Number DG2788ADN-T1-GE4; Mouser Part Number 78-DG2788ADN-T1-GE4
U3, U7: NL3S588; NL3S588MUTBG

Connections:
+3V3: U3.7 (VDD), U7.7 (VDD); also elsewhere on the board
+5V: S1.10 (V+); also elsewhere on the board
/Control/D_uC_N: U3.5 (Dp1); also elsewhere on the board
/Control/D_uC_P: U3.3 (Dn1); also elsewhere on the board
/Control/OE_CC_1: S1.14 (IN1-2); also elsewhere on the board
/Control/OE_CC_2: S1.6 (IN3-4); also elsewhere on the board
/Control/OE_N_SBU: U7.8 (OEN); also elsewhere on the board
/Control/OE_N_USB2: U3.8 (OEN); also elsewhere on the board
/Control/PU_CC: Q3.1 (G), Q6.1 (G), R27.2, R28.2; also elsewhere on the board
/Control/PU_CC_1: Q2.1 (G), Q5.1 (G), R8.2, R21.2; also elsewhere on the board
/Control/PU_CC_2: Q1.1 (G), Q4.1 (G), R7.2, R20.2; also elsewhere on the board
/Control/SEL_USB2_SBU: U3.1 (SEL), U7.1 (SEL); also elsewhere on the board
/USB 2.0 and Misc Signal Switching/CC1: R26.1, R28.1, S1.4 (COM3), S1.12 (COM1); also elsewhere on the board
/USB 2.0 and Misc Signal Switching/CC1_1: R8.1, R12.1, S1.11 (NO1); also elsewhere on the board
/USB 2.0 and Misc Signal Switching/CC1_2: R7.1, R11.1, S1.3 (NO3); also elsewhere on the board
/USB 2.0 and Misc Signal Switching/CC2: R22.1, R27.1, S1.8 (COM4), S1.16 (COM2); also elsewhere on the board
/USB 2.0 and Misc Signal Switching/CC2_1: R21.1, R25.1, S1.15 (NO2); also elsewhere on the board
/USB 2.0 and Misc Signal Switching/CC2_2: R20.1, R24.1, S1.7 (NO4); also elsewhere on the board
/USB 2.0 and Misc Signal Switching/D_1_N: U3.6 (Dp0); also elsewhere on the board
/USB 2.0 and Misc Signal Switching/D_1_P: U3.4 (Dn0); also elsewhere on the board
/USB 2.0 and Misc Signal Switching/D_N: U3.9 (D+); also elsewhere on the board
/USB 2.0 and Misc Signal Switching/D_P: U3.10 (D-); also elsewhere on the board
/USB 2.0 and Misc Signal Switching/SBU1: U7.9 (D+); also elsewhere on the board
/USB 2.0 and Misc Signal Switching/SBU1_1: U7.6 (Dp0); also elsewhere on the board
/USB 2.0 and Misc Signal Switching/SBU1_2: U7.5 (Dp1); also elsewhere on the board
/USB 2.0 and Misc Signal Switching/SBU2: U7.10 (D-); also elsewhere on the board
/USB 2.0 and Misc Signal Switching/SBU2_1: U7.4 (Dn0); also elsewhere on the board
/USB 2.0 and Misc Signal Switching/SBU2_2: U7.3 (Dn1); also elsewhere on the board
GND: Q1.2 (S), Q2.2 (S), Q3.2 (S), Q4.2 (S), Q5.2 (S), Q6.2 (S), S1.2 (GND), U3.2 (GND), U7.2 (GND); also elsewhere on the board
unnamed: Q1.3 (D), R11.2
unnamed: Q2.3 (D), R12.2
unnamed: Q3.3 (D), R22.2
unnamed: Q4.3 (D), R24.2
unnamed: Q5.3 (D), R25.2
unnamed: Q6.3 (D), R26.2

Parts:
C1: 100n; C_0603_1608Metric
C2, C3, C8, C10: 47u; C_1206_3216Metric
D1, D2, D3: D_Schottky_Small; D_SOD-323
F1, F2, F3: 5A; Fuse_0603_1608Metric
L1: 4.7uH; L_0805_2012Metric
NT1: pwr_erc_ignore; NetTie-2_SMD_Pad2.0mm
R4, R5: 10k; R_0603_1608Metric
R9, R10: 470; R_0603_1608Metric
R13, R15, R17: 47k; R_0603_1608Metric
R14, R16, R18: 5.6k; R_0603_1608Metric
R29, R30, R31: 220k; R_0603_1608Metric
U4: AP63205WU; TSOT-23-6
U5, U6: UCS3205-E_Q8A; UCS3205-E&slash_Q8A
U8: AZ1117C-3.3; SOT-89-3

Connections:
+3V3: C3.1, C10.1, U5.4 (DIR), U6.4 (DIR), U8.2 (VO); also elsewhere on the board
+5V: C2.1, L1.2, U4.1 (FB), U8.3 (VI); also elsewhere on the board
/Control/OE_PWR_1: R4.2, U5.2 (EN); also elsewhere on the board
/Control/OE_PWR_2: R5.2, U6.2 (EN); also elsewhere on the board
/Control/VBUS_SNS_IN1: R13.1, R14.2; also elsewhere on the board
/Control/VBUS_SNS_IN2: R15.1, R16.2; also elsewhere on the board
/Control/VBUS_SNS_OUT: R17.1, R18.2; also elsewhere on the board
/Power Switching and Supplies/VBUS: F3.2; also elsewhere on the board
/Power Switching and Supplies/VBUS_1: F1.1; also elsewhere on the board
/Power Switching and Supplies/VBUS_2: F2.1; also elsewhere on the board
/Power Switching and Supplies/VBUS_IN1_FUSED: D1.2 (A), F1.2, R13.2, R29.2, U5.19 (VIN), U5.20 (VIN), U5.21 (VIN)
/Power Switching and Supplies/VBUS_IN2_FUSED: D2.2 (A), F2.2, R15.2, R30.2, U6.19 (VIN), U6.20 (VIN), U6.21 (VIN)
/Power Switching and Supplies/VBUS_OUT_FUSED: D3.2 (A), F3.1, NT1.2, R17.2, R31.2, U6.16 (VOUT), U6.17 (VOUT), U6.22 (VOUT)
GND: C2.2, C3.2, C8.2, C10.2, R4.1, R5.1, R9.2, R10.2, R14.1, R16.1, R18.1, R29.1, R30.1, R31.1, U4.4 (GND), U5.1 (GND), U5.3 (FRS), U5.5 (DSC), U5.12 (LATCH), U5.14 (VOV), U5.15 (GND), U6.1 (GND), U6.3 (FRS), U6.5 (DSC), U6.12 (LATCH), U6.14 (VOV), U6.15 (GND), U8.1 (GND); also elsewhere on the board
unnamed: C1.1, L1.1, U4.5 (SW)
unnamed: C1.2, U4.6 (BST)
unnamed: C8.1, D1.1 (K), D2.1 (K), D3.1 (K), U4.2 (EN), U4.3 (IN)
unnamed: NT1.1, U5.16 (VOUT), U5.17 (VOUT), U5.22 (VOUT)
unnamed: R9.1, U5.13 (ISEN)
unnamed: R10.1, U6.13 (ISEN)

Parts:
C4, C7: 1u; C_0603_1608Metric
C5, C6: 100n; C_0603_1608Metric
D4, D5, D6: LED_Small; LED_0805_2012Metric
D7, D8, D9: 3.6V; D_SOD-523
J4: Conn_02x05_Odd_Even; PinHeader_2x05_P1.27mm_Vertical
R1, R2, R3: 470; R_0603_1608Metric
R19: 1k; R_0603_1608Metric
SW1: SW_Push; SW_SPST_TL3342
U9: ATSAMD21E15B-M; QFN-32-1EP_5x5mm_P0.5mm_EP3.6x3.6mm

Connections:
+3V3: C6.1, C7.1, J4.1, R19.2, SW1.1, U9.9 (VDDANA), U9.30 (VDDIN); also elsewhere on the board
/Control/D_uC_N: U9.23 (PA24); also elsewhere on the board
/Control/D_uC_P: U9.24 (PA25); also elsewhere on the board
/Control/LED_IN_1: R1.1, U9.18 (PA17)
/Control/LED_IN_2: R3.1, U9.17 (PA16)
/Control/LED_OUT: R2.1, U9.4 (PA03)
/Control/OE_CC_1: U9.7 (PA06); also elsewhere on the board
/Control/OE_CC_2: U9.6 (PA05); also elsewhere on the board
/Control/OE_N_SBU: U9.5 (PA04); also elsewhere on the board
/Control/OE_N_USB2: U9.21 (PA22); also elsewhere on the board
/Control/OE_N_USB3: U9.19 (PA18); also elsewhere on the board
/Control/OE_PWR_1: U9.15 (PA14); also elsewhere on the board
/Control/OE_PWR_2: U9.16 (PA15); also elsewhere on the board
/Control/PU_CC: D9.1 (K), U9.14 (PA11); also elsewhere on the board
/Control/PU_CC_1: D8.1 (K), U9.8 (PA07); also elsewhere on the board
/Control/PU_CC_2: D7.1 (K), U9.13 (PA10); also elsewhere on the board
/Control/SEL_USB2_SBU: U9.25 (PA27); also elsewhere on the board
/Control/SEL_USB3: U9.20 (PA19); also elsewhere on the board
/Control/SWDCLK: J4.4, R19.1, U9.31 (PA30)
/Control/SWDIO: J4.2, U9.32 (PA31)
/Control/VBUS_SNS_IN1: U9.11 (PA08); also elsewhere on the board
/Control/VBUS_SNS_IN2: U9.12 (PA09); also elsewhere on the board
/Control/VBUS_SNS_OUT: U9.3 (PA02); also elsewhere on the board
GND: C4.2, C5.2, C6.2, C7.2, D4.1 (K), D5.1 (K), D6.1 (K), D7.2 (A), D8.2 (A), D9.2 (A), J4.3, J4.5, J4.7, J4.9, U9.10 (GND), U9.28 (GND); also elsewhere on the board
unnamed: C4.1, C5.1, U9.29 (VDDCORE)
unnamed: D4.2 (A), R3.2
unnamed: D5.2 (A), R1.2
unnamed: D6.2 (A), R2.2
unnamed: J4.10, U9.26 (~RESET)
unnamed: SW1.2, U9.1 (PA00)

Board: 6 copper layers, 48.5 x 50.0 mm, 83 parts (3 on the bottom side), 90 nets.

Other parts of the board:
REF_KICAD_LOGO: KiCad-Logo2_5mm_SilkScreen
REF_OSH_LOGO_1: OSHW-Logo_5.7x6mm_SilkScreen
REF_OSH_LOGO_2: OSHW-Logo2_9.8x8mm_SilkScreen

File KiCad/gerbers/USB-TypeC-Switch-BOM-JLCPCB.csv:

Comment,Designator,Footprint,LCSC
1u,"C4,C7",Capacitor_SMD:C_0603_1608Metric,C15849
100n,"C1,C5,C6,C9",Capacitor_SMD:C_0603_1608Metric,C14663
"3.6V, Zener Diode","D7,D8,D9",Diode_SMD:D_SOD-523,C968169
TPM2008P3,"Q1,Q2,Q3,Q4,Q5,Q6",Package_DFN_QFN:Diodes_DFN1006-3,C708974
5.1k,"R11,R12,R22,R24,R25,R26",Resistor_SMD:R_0402_1005Metric,C25905
220k,"R7,R8,R20,R21,R27,R28",Resistor_SMD:R_0402_1005Metric,C25767
47k,"R13,R15,R17,R23",Resistor_SMD:R_0603_1608Metric,C25819
470,"R1,R2,R3,R9,R10",Resistor_SMD:R_0603_1608Metric,C23179
5.6k,"R14,R16,R18,R19",Resistor_SMD:R_0603_1608Metric,C23189
220k,"R29,R30,R31",Resistor_SMD:R_0603_1608Metric,C22961
10k,"R4,R5,R6",Resistor_SMD:R_0603_1608Metric,C25804

Notices in the files:
Firmware/hardware/type_c_switch_samd21e15/samd/variants/samd21e15/variant.cpp:
Copyright (c) 2014-2015 Arduino LLC.  All right reserved.
KiCad/USB-TypeC-Switch.kicad_pcb:
License:
CC BY 4.0 (Attribution 4.0 Intl.)
parts and their libraries:
Copyright 2016 Accelerated Designs. All rights reserved.
