# Repository bluetiger9/USB-Type-C-Switch (continued)

## KiCad design KiCad/USB-TypeC-Switch_top_bottom.kicad_pcb

Board: 4 copper layers, 51 parts (2 on the bottom side), 77 nets.

Parts:
C1, C5, C6: 100n; C_0805_2012Metric
C2, C3: 47u; C_0805_2012Metric
C4, C7: 1u; C_0805_2012Metric
D1, D2, D3: D_Small; D_0805_2012Metric
D4: LED_Small; LED_0805_2012Metric
F1, F2, F3: 3A; R_0805_2012Metric
J1: USB_C_IN_1; USB_C_Receptacle_Amphenol_12401548E4-2A
J2: USB_C_IN_2; USB_C_Receptacle_Amphenol_12401548E4-2A
J3: USB_C_OUT; USB_C_Receptacle_Amphenol_12401548E4-2A
J4: Conn_02x05_Odd_Even; Tag-Connect_TC2050-IDC-FP_2x05_P1.27mm_Vertical
L1: 4.7uH; L_0805_2012Metric
NT1: pwr_erc_ignore; NetTie-2_SMD_Pad0.5mm
R1, R2, R3, R4, R5, R6, R7, R8: 1k; R_0603_1608Metric
R9, R10: 470; R_0805_2012Metric
R11, R12: 200; R_0805_2012Metric
R13, R15, R17: 9k; R_0805_2012Metric
R14, R16, R18, R19: 1k; R_0805_2012Metric
R20: 220; R_0805_2012Metric
R23: 30; R_0805_2012Metric
S1: DG2788ADN-T1-GE4; QFN40P180X260X60-16N-D
U1, U2: FUSB340TMX; QFN40P200X280X40-19N
U3, U7: NL3S588; IC_TPD6E001RSER
U4: AP63205WU; TSOT-23-6
U5, U6: UCS3205-E_Q8A; UCS3205-E&slash_Q8A
U8: AZ1117-3.3; SOT-89-3
U9: ATSAMD21G15B-M; QFN-48-1EP_7x7mm_P0.5mm_EP5.15x5.15mm

Connections:
+1V8: R1.1, R2.1, R3.1, R4.1, R5.1, R6.1, R7.1, R8.1, R11.1, R12.2
+3V3: C3.1, C6.1, C7.1, J4.1, R11.2, R19.2, U1.17, U2.17, U3.7, U5.4, U6.4, U7.7, U8.2, U9.6, U9.17, U9.36, U9.44
+5V: C2.1, L1.2, S1.10, U4.1, U8.3
/Control/OE_CC_1: S1.4, S1.12, U9.27
/Control/OE_CC_2: S1.8, S1.16, U9.28
/Control/OE_N_SBU: U7.8, U9.26
/Control/OE_N_USB2: U3.8, U9.25
/Control/OE_PWR_1: U5.2, U9.22
/Control/OE_PWR_2: U6.2, U9.23
/Control/VBUS_SNS_IN1: R13.1, R14.2, U9.14
/Control/VBUS_SNS_IN2: R15.1, R16.2, U9.15
/Control/VBUS_SNS_OUT: R17.1, R18.2, U9.16
/Power Switching and Supplies/VBUS: F3.2, J3.A4, J3.A9, J3.B4, J3.B9
/Power Switching and Supplies/VBUS_1: F1.1, J1.A4, J1.A9, J1.B4, J1.B9
/Power Switching and Supplies/VBUS_2: F2.1, J2.A4, J2.A9, J2.B4, J2.B9
/USB 2.0 and Misc Signal Switching/CC1: J3.A5, S1.14
/USB 2.0 and Misc Signal Switching/CC1_1: J1.A5, S1.11
/USB 2.0 and Misc Signal Switching/CC1_2: J2.A5, S1.15
/USB 2.0 and Misc Signal Switching/CC2: J3.B5, S1.6
/USB 2.0 and Misc Signal Switching/CC2_1: J1.B5, S1.3
/USB 2.0 and Misc Signal Switching/CC2_2: J2.B5, S1.7
/USB 2.0 and Misc Signal Switching/D_1_N: J1.A7, J1.B7, U3.4
/USB 2.0 and Misc Signal Switching/D_1_P: J1.A6, J1.B6, U3.6
/USB 2.0 and Misc Signal Switching/D_2_N: J2.A7, J2.B7, U3.3
/USB 2.0 and Misc Signal Switching/D_2_P: J2.A6, J2.B6, U3.5
/USB 2.0 and Misc Signal Switching/D_N: J3.A6, J3.B6, U3.10, U9.33
/USB 2.0 and Misc Signal Switching/D_P: J3.A7, J3.B7, U3.9, U9.34
/USB 2.0 and Misc Signal Switching/SBU1: J3.A8, U7.9
/USB 2.0 and Misc Signal Switching/SBU1_1: J1.A8, U7.6
/USB 2.0 and Misc Signal Switching/SBU1_2: J2.A8, U7.5
/USB 2.0 and Misc Signal Switching/SBU2: J3.B8, U7.10
/USB 2.0 and Misc Signal Switching/SBU2_1: J1.B8, U7.4
/USB 2.0 and Misc Signal Switching/SBU2_2: J2.B8, U7.3
/USB 2.0 and Misc Signal Switching/SEL: U3.1, U7.1, U9.24
/USB 3 Signal Switching/OE_N: U1.7, U2.7, U9.30
/USB 3 Signal Switching/RX1_1_N: J1.B10, U1.11
/USB 3 Signal Switching/RX1_1_P: J1.B11, U1.10
/USB 3 Signal Switching/RX1_2_N: J2.B10, U1.9
/USB 3 Signal Switching/RX1_2_P: J2.B11, U1.8
/USB 3 Signal Switching/RX1_N: J3.B10, R6.2, U1.4
/USB 3 Signal Switching/RX1_P: J3.B11, R8.2, U1.5
/USB 3 Signal Switching/RX2_1_N: J1.A10, U2.11
/USB 3 Signal Switching/RX2_1_P: J1.A11, U2.10
/USB 3 Signal Switching/RX2_2_N: J2.A10, U2.9
/USB 3 Signal Switching/RX2_2_P: J2.A11, U2.8
/USB 3 Signal Switching/RX2_N: J3.A10, R3.2, U2.4
/USB 3 Signal Switching/RX2_P: J3.A11, R1.2, U2.5
/USB 3 Signal Switching/SEL: U1.6, U2.6, U9.29
/USB 3 Signal Switching/TX1_1_N: J1.A3, U2.16
/USB 3 Signal Switching/TX1_1_P: J1.A2, U2.15
/USB 3 Signal Switching/TX1_2_N: J2.A3, U2.14
/USB 3 Signal Switching/TX1_2_P: J2.A2, U2.13
/USB 3 Signal Switching/TX1_N: J3.A3, R7.2, U2.1
/USB 3 Signal Switching/TX1_P: J3.A2, R5.2, U2.2
/USB 3 Signal Switching/TX2_1_N: J1.B3, U1.16
/USB 3 Signal Switching/TX2_1_P: J1.B2, U1.15
/USB 3 Signal Switching/TX2_2_N: J2.B3, U1.14
/USB 3 Signal Switching/TX2_2_P: J2.B2, U1.13
/USB 3 Signal Switching/TX2_N: J3.B3, R2.2, U1.1
/USB 3 Signal Switching/TX2_P: J3.B2, R4.2, U1.2
GND: C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, D4.1, J1.A1, J1.A12, J1.B1, J1.B12, J2.A1, J2.A12, J2.B1, J2.B12, J3.A1, J3.A12, J3.B1, J3.B12, J4.3, J4.5, J4.7, J4.9, R9.2, R10.2, R12.1, R14.1, R16.1, R18.1, R23.1, S1.2, U1.3, U1.12, U1.18, U1.19, U2.3, U2.12, U2.18, U2.19, U3.2, U4.4, U5.1, U5.3, U5.5, U5.12, U5.14, U5.15, U6.1, U6.3, U6.5, U6.12, U6.14, U6.15, U7.2, U8.1, U9.5, U9.18, U9.35, U9.42
GNDS: J1.S1, J2.S1, J3.S1, R23.2
unnamed: C1.1, L1.1, U4.5
unnamed: C1.2, U4.6
unnamed: C4.1, C5.1, U9.43
unnamed: D1.1, D2.1, D3.1, U4.2, U4.3
unnamed: D1.2, F1.2, R13.2, U5.19, U5.20, U5.21
unnamed: D2.2, F2.2, R15.2, U6.19, U6.20, U6.21
unnamed: D3.2, F3.1, NT1.2, R17.2, U6.16, U6.17, U6.22
unnamed: D4.2, R20.2
unnamed: J4.2, R19.1, U9.45
unnamed: J4.4, U9.46
unnamed: J4.10, U9.40
unnamed: NT1.1, U5.16, U5.17, U5.22
unnamed: R9.1, U5.13
unnamed: R10.1, U6.13
unnamed: R20.1, U9.11

## Code that names these connections

File Firmware/Type-C-Switch/Type-C-Switch.ino:

/*
 * USB 3.x Type-C Switch
 *
 * Copyright (C) Attila Tőkés
 *
 * Licence: MIT
 *
 */

/* Pin Definitions */
const uint8_t PIN_BUTTON = 0;

const uint8_t PIN_LED_OUT = 3;
const uint8_t PIN_LED_IN1 = 17;
const uint8_t PIN_LED_IN2 = 16;

const uint8_t PIN_VBUS_SNS_OUT = 2;
const uint8_t PIN_VBUS_SNS_IN1 = 8;
const uint8_t PIN_VBUS_SNS_IN2 = 9;

const uint8_t PIN_OE_N_SBU = 4;
const uint8_t PIN_OE_CC_1 = 6;
const uint8_t PIN_OE_CC_2 = 5;

const uint8_t PIN_OE_PWR_1 = 14;
const uint8_t PIN_OE_PWR_2 = 15;

const uint8_t PIN_OE_N_USB3 = 18;
const uint8_t PIN_SEL_USB3 = 19;

const uint8_t PIN_OE_N_USB2 = 22;
const uint8_t PIN_SEL_USB2_SBU = 27;

const uint8_t PIN_USB_N_uC = 24;
const uint8_t PIN_USB_P_uC = 25;

// Power Delivery Trigger circuits
const uint8_t PIN_CC_PD_TRG = 11;
const uint8_t PIN_CC_1_PD_TRG= 8;
const uint8_t PIN_CC_2_PD_TRG = 13;

/* Pin Values */
const int8_t OFF = LOW;
const int8_t ON = HIGH;

const int8_t OFF_N = HIGH;
const int8_t ON_N = LOW;

const int8_t UNCHANGED = -1;

const int8_t SEL_IN1 = LOW;
const int8_t SEL_IN2 = HIGH;

const int8_t SEL_IN1_N = HIGH;
const int8_t SEL_IN2_N = LOW;

/* Voltage Sensing */

/* voltage divider: 47k / 5.6k = 8.39 ~= 67 / 2^3 */
const int V_SNS_MULTIP = 67;
const int V_SNS_SHIFT = 3;

/* threshold voltage: ~ 1.5 V */
const int V_SNS_TH = 4096.0 / 3.3 * 1.5;

/* States */
typedef struct State {
  int8_t oe_n_sbu;
  int8_t oe_cc_1;
  int8_t oe_cc_2;

  int8_t oe_pwr_1;
  int8_t oe_pwr_2;

  int8_t oe_n_usb3;
  int8_t on_n_usb2;

  int8_t sel_usb3;
  int8_t sel_usb2_sbu;

  int8_t led_out;
  int8_t led_in1;
  int8_t led_in2;

  int8_t cc_pd_trg;
  int8_t cc_pd_trg_1;
  int8_t cc_pd_trg_2;

  bool oe_before_select;
};

/* OFF (Idle) */
const State STATE_OFF = {
  oe_n_sbu : OFF_N,
  oe_cc_1 : OFF,
  oe_cc_2 : OFF,
  oe_pwr_1 : OFF,
  oe_pwr_2 : OFF,
  oe_n_usb3 : OFF_N,
  on_n_usb2 : OFF_N,
  sel_usb3 : SEL_IN1_N,
  sel_usb2_sbu : SEL_IN1,
  led_out : ON,
  led_in1 : OFF,
  led_in2 : OFF,
  cc_pd_trg : ON,
  cc_pd_trg_1 : ON,
  cc_pd_trg_2 : ON,
  oe_before_select: true
};

/* IN1 <--> OUT */
const State STATE_ON_IN1 = {
  oe_n_sbu: ON_N,
  oe_cc_1: ON,
  oe_cc_2: OFF,
  oe_pwr_1: ON,
  oe_pwr_2: OFF,
  oe_n_usb3: ON_N,
  on_n_usb2: ON_N,
  sel_usb3: SEL_IN1_N,
  sel_usb2_sbu: SEL_IN1,
  led_out : ON,
  led_in1 : ON,
  led_in2 : OFF,
  cc_pd_trg : OFF,
  cc_pd_trg_1 : OFF,
  cc_pd_trg_2 : ON,
  oe_before_select: false
};

/* IN2 <--> OUT */
const State STATE_ON_IN2 = {
  oe_n_sbu: ON_N,
  oe_cc_1: OFF,
  oe_cc_2: ON,
  oe_pwr_1: OFF,
  oe_pwr_2: ON,
  oe_n_usb3: ON_N,
  on_n_usb2: ON_N,
  sel_usb3: SEL_IN2_N,
  sel_usb2_sbu: SEL_IN2,
  led_out : ON,
  led_in1 : OFF,
  led_in2 : ON,
  cc_pd_trg : OFF,
  cc_pd_trg_1 : ON,
  cc_pd_trg_2 : OFF,
  oe_before_select: false
};

const State *state = &STATE_OFF;

const uint16_t STATE_CHANGE_DELAY = 500;

/* Button (low pass filter) */
bool buttonReleased = true;
const uint16_t BUTTON_CHECK_DELAY = 100;

/* Auto switch ignore / delay */
const uint16_t AUTO_SWITCH_DELAY = 5000;
int64_t autoSwitchNotBefore = -1;

/* Input / output */

void pinModeOut(int pin, int initialValue) {
  digitalWrite(pin, initialValue);
  pinMode(pin, OUTPUT);
  digitalWrite(pin, initialValue);
}

bool detectVoltage(int snsPin) {
  int volt = (analogRead(snsPin) * V_SNS_MULTIP) >> V_SNS_SHIFT;
  return volt > V_SNS_TH;
}

void initPins() {
  pinMode(PIN_BUTTON, INPUT_PULLDOWN);
  pinMode(PIN_VBUS_SNS_OUT, INPUT);
  pinMode(PIN_VBUS_SNS_IN1, INPUT);
  pinMode(PIN_VBUS_SNS_IN2, INPUT);

  // disable internal USB port
  pinMode(PIN_USB_N_uC, INPUT);
  pinMode(PIN_USB_P_uC, INPUT);

  pinModeOut(PIN_LED_OUT, STATE_OFF.led_out);
  pinModeOut(PIN_LED_IN1, STATE_OFF.led_in1);
  pinModeOut(PIN_LED_IN2, STATE_OFF.led_in2);
  pinModeOut(PIN_OE_N_SBU, STATE_OFF.oe_n_sbu);
  pinModeOut(PIN_OE_CC_1, STATE_OFF.oe_cc_1);
  pinModeOut(PIN_OE_CC_2, STATE_OFF.oe_cc_2);
  pinModeOut(PIN_OE_PWR_1, STATE_OFF.oe_pwr_1);
  pinModeOut(PIN_OE_PWR_2, STATE_OFF.oe_pwr_2);
  pinModeOut(PIN_OE_N_USB3, STATE_OFF.oe_n_usb3);
  pinModeOut(PIN_SEL_USB3, STATE_OFF.sel_usb3);
  pinModeOut(PIN_OE_N_USB2, STATE_OFF.on_n_usb2);
  pinModeOut(PIN_SEL_USB2_SBU, STATE_OFF.sel_usb2_sbu);
  pinModeOut(PIN_CC_PD_TRG, STATE_OFF.cc_pd_trg);
  pinModeOut(PIN_CC_1_PD_TRG, STATE_OFF.cc_pd_trg_1);
  pinModeOut(PIN_CC_2_PD_TRG, STATE_OFF.cc_pd_trg_2);
}

/* State handling */

void changeStateOE(State state) {
  digitalWrite(PIN_OE_N_SBU, state.oe_n_sbu);
  digitalWrite(PIN_OE_CC_1, state.oe_cc_1);
  digitalWrite(PIN_OE_CC_2, state.oe_cc_2);
  digitalWrite(PIN_OE_PWR_1, state.oe_pwr_1);
  digitalWrite(PIN_OE_PWR_2, state.oe_pwr_2);
  digitalWrite(PIN_OE_N_USB3, state.oe_n_usb3);
  digitalWrite(PIN_OE_N_USB2, state.on_n_usb2);
  digitalWrite(PIN_CC_PD_TRG, state.cc_pd_trg);
  digitalWrite(PIN_CC_1_PD_TRG, state.cc_pd_trg_1);
  digitalWrite(PIN_CC_2_PD_TRG, state.cc_pd_trg_2);
}

void changeStateSEL(State state) {
  digitalWrite(PIN_SEL_USB3, state.sel_usb3);
  digitalWrite(PIN_SEL_USB2_SBU, state.sel_usb2_sbu);
  digitalWrite(PIN_LED_OUT, state.led_out);
  digitalWrite(PIN_LED_IN1, state.led_in1);
  digitalWrite(PIN_LED_IN2, state.led_in2);
}

void changeState(const State *newState) {
  state = newState;
  if (state->oe_before_select) {
    changeStateOE(*newState);
    changeStateSEL(*newState);

  } else {
    changeStateOE(*newState);
    changeStateSEL(*newState);
  }
}

void changeStateSafely(const State *newState) {
  changeState(&STATE_OFF);

  autoSwitchNotBefore = millis() + AUTO_SWITCH_DELAY;

  if (newState != &STATE_OFF) {
    delay(STATE_CHANGE_DELAY);
    changeState(newState);
  }
}

const State* nextState() {
  if (state == &STATE_OFF) {
    return &STATE_ON_IN1;

  } if (state == &STATE_ON_IN1) {
    return &STATE_ON_IN2;

  } if (state == &STATE_ON_IN2) {
    return &STATE_OFF;

  } else {
    return &STATE_OFF;
  }
}

/* Setup */

void setup() {
  analogReadResolution(12);

  initPins();
}

/* Loop */
void loop() {
  auto now = millis();

  // Idle and new device is pluged into IN1?
  if (state != &STATE_ON_IN1 && detectVoltage(PIN_VBUS_SNS_IN1) && !detectVoltage(PIN_VBUS_SNS_IN2) && now >= autoSwitchNotBefore) {
    changeStateSafely(&STATE_ON_IN1);
    return;
  }

  // Idle and new device is pluged into IN2?
  if (state != &STATE_ON_IN2 && detectVoltage(PIN_VBUS_SNS_IN2) && !detectVoltage(PIN_VBUS_SNS_IN1) && now >= autoSwitchNotBefore) {
    changeStateSafely(&STATE_ON_IN2);
    return;
  }

  // Was the Button pressed?
  auto button = digitalRead(PIN_BUTTON);
  if (button == HIGH && buttonReleased) {
    delay(BUTTON_CHECK_DELAY);
    if (digitalRead(PIN_BUTTON) == HIGH) {
      changeStateSafely(nextState());
      buttonReleased = false;
    }

  } else if (button == LOW) {
    buttonReleased = true;
  }
}

File Firmware/hardware/type_c_switch_samd21e15/samd/variants/samd21e15/variant.cpp (part):

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 * +------------+------------------+--------+-----------------+--------------------------------------------------------------------------------------------------------
 * |            | Digital Low      |        |                 |
 * +------------+------------------+--------+-----------------+--------------------------------------------------------------------------------------------------------
 * | 0          | D0               |  PA04  | D0/A2/SDA/TX    | EIC/EXTINT[4]  ADC/AIN[4]  AC/AIN[0] PTC/Y[2]  SERCOM0/PAD[0]                  *TCC0/WO[0]
 * | 1          | D1               |  PA02  | D1/A0/VOUT      | EIC/EXTINT[2]  ADC/AIN[0] *DAC/VOUT  PTC/Y[0]
 * | 2          | D2               |  PA05  | D2/A1/SCL/RX    | EIC/EXTINT[5]  ADC/AIN[5]  AC/AIN[1] PTC/Y[5]  SERCOM0/PAD[1]                  *TCC0/WO[1]
 * | 3          | Dotstar Data     |  PA00  |                 |
 * | 4          | DotStar Clock    |  PA01  |                 |
 * +------------+------------------+--------+-----------------+--------------------------------------------------------------------------------------------------------
 * |            | USB              |        |                 |
 * +------------+------------------+--------+-----------------+--------------------------------------------------------------------------------------------------------
 * | 5          |                  |  PA28  | USB_HOST_ENABLE | EIC/EXTINT[8]
 * | 6          |                  |  PA24  | USB_NEGATIVE    | *USB/DM
 * | 7          |                  |  PA25  | USB_POSITIVE    | *USB/DP
 * +------------+------------------+--------+-----------------+--------------------------------------------------------------------------------------------------------
 * |            | Analog Pins      |        |                 |
 * +------------+------------------+--------+-----------------+--------------------------------------------------------------------------------------------------------
 * | 8          | A0               |  PA02  | D1/A0/VOUT      | EIC/EXTINT[2] *ADC/AIN[0]  DAC/VOUT  PTC/Y[0]
 * | 9          | A1               |  PA05  | D2/A1/SCL/RX    | EIC/EXTINT[5] *ADC/AIN[5]  AC/AIN[1] PTC/Y[5]  SERCOM0/PAD[1]                  TCC0/WO[1]
 * | 10         | A2               |  PA04  | D0/A2/SDA/TX    | EIC/EXTINT[4] *ADC/AIN[4]  AC/AIN[0] PTC/Y[2]  SERCOM0/PAD[0]                  TCC0/WO[0]
 * +------------+------------------+--------+-----------------+--------------------------------------------------------------------------------------------------------
 * |            | SWD              |        |                 |
 * +------------+------------------+--------+-----------------+--------------------------------------------------------------------------------------------------------
 * | 11         |                  |  PA30  | SWD Clock       |
 * | 12         |                  |  PA31  | SWD Data        |
 * +------------+------------------+--------+-----------------+--------------------------------------------------------------------------------------------------------
 * |            | Digital High     |        |                 |
 * +------------+------------------+--------+-----------------+--------------------------------------------------------------------------------------------------------
 * | 13         | 13               |  PA23  | LED             | EIC/EXTINT[7]                        PTC/X[11] *SERCOM3/PAD[1] SERCOM5/PAD[1] TC4/WO[1] TCC0/WO[5]
 * | 14         | 14               |  PA10  | RXLED           | EIC/EXTINT[10] ADC/AIN[18]           PTC/X[2] *SERCOM0/PAD[2]                  TCC0/WO[2]  TCC1/WO[0]
 * | 15         | 15               |  PA11  | TXLED           | EIC/EXTINT[11] ADC/AIN[19]           PTC/X[3] *SERCOM0/PAD[3]  SERCOM2/PAD[3]  TCC0/WO[3]  TCC1/WO[1]
 * +------------+------------------+--------+-----------------+--------------------------------------------------------------------------------------------------------
 */

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
## Commit log

2021-01-23 Silkscreen, Gerbers, Renders
2021-02-28 Basic Firmware
2022-11-20 Migrate to KiCad 6.x
2022-11-20 Fix R17/R18 reference placement
2022-11-20 Fix USB 2.0 signal polarity (+others)
2022-11-21 Use 0603 resistors and capacitors
2022-11-21 6 layers
2022-11-21 6 layers partial routing
2022-11-23 CC detect trigger + inner layer routing
2022-11-25 6 layer re-routing
2022-11-26 resistor value + stitching vias
2022-11-26 6 layer 1.6mm stackup + gerbers + bom + position files
2022-11-27 fix 3d models
2023-01-03 add PULLDOWN for button input
2023-01-07 Add PD trigger enable pins
2023-01-07 Add auto-switch delay
2023-01-07 Disable internal USB pins
2023-01-07 Fix USB 3.0 select lines
2024-08-10 update footprints + render
2024-08-10 update footprints + render + power pull-ups
