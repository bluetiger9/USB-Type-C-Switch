File: KiCad/h_control.kicad_sch (KiCad schematic)
At the start: 17 parts, among them J4 Conn_02x05_Odd_Even, SW1 SW_Push, U9 ATSAMD21E15B-M

Commit message: update footprints + render + power pull-ups
