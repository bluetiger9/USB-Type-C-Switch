File: KiCad/h_usb2_misc.kicad_sch (KiCad schematic)
At the start: 21 parts, among them Q1 AP1606, Q2 AP1606, Q3 AP1606, Q4 AP1606, Q5 AP1606, Q6 AP1606, U3 NL3S588, U7 NL3S588

Commit message: update footprints + render + power pull-ups
Parts:
- R20, R21, R27, R28, R7, R8: value 220k -> 47k
